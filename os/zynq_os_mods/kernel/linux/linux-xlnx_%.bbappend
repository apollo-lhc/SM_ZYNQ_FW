SRC_URI += "file://user_2019-05-30-15-53-00.cfg"
SRC_URI += "file://sgmii.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

