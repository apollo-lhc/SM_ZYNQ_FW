SRC_URI_append += " file://0001-MIO-pin-26-added-to-pinctrl-ethernet0-group.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
